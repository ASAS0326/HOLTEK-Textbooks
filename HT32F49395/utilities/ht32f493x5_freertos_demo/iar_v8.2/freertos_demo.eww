<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\freertos_demo.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>freertos_demo</project>
                <configuration>ht32f49395_sk</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
