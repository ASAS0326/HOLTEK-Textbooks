# IAR project freertos_demo.ewp, settings and files
configuration ht32f49395_sk (ARM, debug)
  General.OGChipSelectEditMenu: HT32F49395_100LQFP Holtek HT32F49395_100LQFP
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_HT32F49395_SK; USE_HT32F49395_100LQFP
  ICCARM.CCIncludePath2: ..\..\..\libraries\drivers\inc; ..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\libraries\cmsis\cm4\device_support; ..\..\..\middlewares\freertos\source\include; ..\..\..\middlewares\freertos\source\portable\IAR\ARM_CM4F; ..\inc; ..\..\..\project\ht32f493x5_board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\middlewares\freertos\source\portable\IAR\ARM_CM4F; ..\inc
  OBJCOPY.OOCOutputFile: freertos_demo.hex
  ILINK.IlinkOutputFile: freertos_demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../project/ht32f493x5_board/: ht32f493x5_board.c
  group cmsis
    ../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_ht32f493x5.s
    ../../../libraries/cmsis/cm4/device_support/: system_ht32f493x5.c
  group firmware
    ../../../libraries/drivers/src/: ht32f493x5_acc.c ht32f493x5_adc.c ht32f493x5_bpr.c ht32f493x5_can.c ht32f493x5_crc.c ht32f493x5_crm.c ht32f493x5_dac.c ht32f493x5_debug.c ht32f493x5_dma.c ht32f493x5_exint.c ht32f493x5_flash.c ht32f493x5_gpio.c ht32f493x5_i2c.c ht32f493x5_misc.c ht32f493x5_pwc.c ht32f493x5_rtc.c ht32f493x5_sdio.c ht32f493x5_spi.c ht32f493x5_tmr.c ht32f493x5_usart.c ht32f493x5_usb.c ht32f493x5_wdt.c ht32f493x5_wwdt.c ht32f493x5_xmc.c
  group freertos
    ../../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../middlewares/freertos/source/portable/memmang/: heap_4.c
    ../../../middlewares/freertos/source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group readme
    ../: readme.txt
  group user
    ../src/: ht32f493x5_clock.c ht32f493x5_int.c main.c
