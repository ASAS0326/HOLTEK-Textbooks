# Keil uVision project run_classification.uvprojx, settings and files
target run_classification (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: HT32F49395_100LQFP Holtek
  pack: Holtek.HT32F493x5_DFP.1.0.6
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: run_classification
  group user
    ../src/: ht32f493x5_clock.c ht32f493x5_int.c main.c hm01b0.c ei_classifier_porting.cpp ei_main.cpp
  group bsp
    ../../../../../ht32f493x5_board/: ht32f493x5_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: ht32f493x5_crm.c ht32f493x5_usart.c ht32f493x5_gpio.c ht32f493x5_misc.c ht32f493x5_exint.c ht32f493x5_tmr.c ht32f493x5_i2c.c ht32f493x5_dma.c
    ../../../../../../middlewares/i2c_application_library/: i2c_application.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_ht32f493x5.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/gcc/: startup_ht32f493x5.s
  group readme
    ../: readme.txt
software components: CMSIS:CORE 6.1.1, CMSIS:DSP 1.16.2, CMSIS:NN Lib 4.0.0, EdgeImpulse:SDK 1.95.10, EdgeImpulse:model:HOLTEK_Image_Classification 15.0.0
