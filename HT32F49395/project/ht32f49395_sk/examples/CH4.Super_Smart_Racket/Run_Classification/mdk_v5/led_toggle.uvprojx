# Keil uVision project led_toggle.uvprojx, settings and files
target led_toggle (6230000::V6.23::ARMCLANG)
  device: HT32F49395_100LQFP Holtek
  pack: Holtek.HT32F493x5_DFP.1.0.6
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: led_toggle
  group user
    ../src/: ht32f493x5_clock.c ht32f493x5_int.c main.c
    ./: ei_classifier_porting.cpp ei_main.h ei_main.cpp LSM6DS3.c LSM6DS3.h ble_uart4.c ble_uart4.h
  group bsp
    ../../../../../ht32f493x5_board/: ht32f493x5_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: ht32f493x5_crm.c ht32f493x5_usart.c ht32f493x5_gpio.c ht32f493x5_misc.c ht32f493x5_i2c.c ht32f493x5_dma.c ht32f493x5_adc.c ht32f493x5_spi.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_ht32f493x5.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/gcc/: startup_ht32f493x5.s
  group readme
    ../: readme.txt
software components: CMSIS:CORE 6.1.1, CMSIS:DSP 1.16.2, CMSIS:NN Lib 4.0.0, EdgeImpulse:SDK 1.95.14, EdgeImpulse:model:pinpon2 7.0.0
