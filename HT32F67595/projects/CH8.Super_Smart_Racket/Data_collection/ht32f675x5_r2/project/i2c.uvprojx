# Keil uVision project i2c.uvprojx, settings and files
target i2c (6240000::V6.24::ARMCLANG)
  device: HT32F67595_120BGA:CM33 Holtek
  pack: Holtek.HT32F675x5_DFP.1.0.6
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: i2c +hex
  AfterMake: fromelf.exe --text -c -o "$L@L.asm"  "!L"
  AfterMake: cmd /c copy /y .\Objects\i2c.hex ..\hex\i2c.hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MAIN_PROCESSOR HT32F67575_EVB
  c include: ..\..\..\..\..\third_party\CMSIS\5.7.0\CMSIS\Include;..\..\..\..\..\sources\device\ht32f675x5\Include;..\..\..\..\..\sources\drivers\ht32f675x5_r2\ht32\register;..\..\..\..\..\sources\drivers\ht32f675x5_r2\ht32\hw\inc;..\..\..\..\..\sources\drivers\ht32f675x5_r2\ht32\hal\inc;..\..\..\..\..\sources\drivers\ht32f675x5_r2\ext_flash;..\..\..\..\..\sources\patch\ht32f675x5_patch_lib_r2\patch_hw\inc;..\..\..\..\..\sources\patch\ht32f675x5_patch_lib_r2\patch_hal\inc;..\..\..\..\..\sources\boards;..\..\..\..\..\sources\components\ht32f675x5_r2\app_debug;..\..\..\..\..\sources\components\ht32f675x5_r2\err_debug;..\..\..\..\..\sources\components\ht32f675x5_r2\rom_callback;..\..\..\..\..\sources\components\ht32f675x5_r2\utility;..\..\..\..\..\sources\mem_cfg;..\config;.\RTE\_i2c;..\project
  asm define: __MAIN_PROCESSOR
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\i2c.sct
  link misc: --entry=Reset_Handler --keep=g_boot2LibCode
  group Startup Code
    ../../../../../sources/device/ht32f675x5/Source/ARM/: startup_ARMCM33.s
    ../../../../../sources/device/ht32f675x5/Source/: system_ARMCM33.c
  group lib
    ../../../../../libraries/rom/: ht32f675x5_rom_lib_mp_r2.lib
    ../../../../../libraries/boot2/: ht32f675x5_boot2_lib_r2_v1.1.c
    ../../../../../libraries/patch/: ht32f675x5_patch_lib_mp_r2.lib
  group debug
    ../../../../../sources/components/ht32f675x5_r2/app_debug/: app_debug.c
    ../../../../../sources/components/ht32f675x5_r2/err_debug/: err_debug.c
  group main
    ../: main.c
    ./: i2c.c i2c.h LSM6DS3.c LSM6DS3.h
software components: CMSIS:CORE 5.4.0
