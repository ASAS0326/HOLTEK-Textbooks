# Keil uVision project gpio.uvprojx, settings and files
target gpio (6240000::V6.24::ARMCLANG)
  device: HT32F67595_28LGA:CM33 Holtek
  pack: Holtek.HT32F675x5_DFP.1.0.6
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: gpio
  group Startup Code
    ../../../../../sources/device/ht32f675x5/Source/: system_ARMCM33.c
    ../../../../../sources/device/ht32f675x5/Source/GCC/: startup_ARMCM33_gcc.s
  group lib
    ../../../../../libraries/boot2/: ht32f675x5_boot2_lib_r2_v1.1.c
    ../../../../../libraries/patch/: ht32f675x5_patch_lib_mp_r2.a
    ../../../../../libraries/rom/: ht32f675x5_rom_lib_mp_r2.a
  group components
    ../../../../../sources/components/ht32f675x5_r2/app_debug/: app_debug.c
    ../../../../../sources/components/ht32f675x5_r2/err_debug/: err_debug.c
  group main
    ../: main.c
    ../inc/: I2S.h SPH0645LM4H.h ei_main.h
    ../src/: I2S.c SPH0645LM4H.c ei_main.cpp
software components: CMSIS:CORE 6.2.0, CMSIS:DSP 1.16.2, CMSIS:NN Lib 4.0.0, EdgeImpulse:SDK 1.95.13, EdgeImpulse:model:baby_cry 5.0.0
